# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\BEEP;..\HARDWARE\LCD;..\USMART;..\HARDWARE\transplant\TOUCH;..\HARDWARE\EXIT;..\HARDWARE\transplant\24CXX;..\HARDWARE\transplant\IIC;..\HARDWARE\transplant\W25QXX;..\HARDWARE\transplant\SPI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c chess.c check.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c displayChess.c
    ../HARDWARE/EXIT/: exti.c
    ../HARDWARE/transplant/24CXX/: 24cxx.c
    ../HARDWARE/transplant/IIC/: myiic.c
    ../HARDWARE/transplant/SPI/: spi.c
    ../HARDWARE/transplant/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/transplant/W25QXX/: w25qxx.c
    ../HARDWARE/BEEP/: beep.c
    ./: font.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_spi.c
  group README
    ../: README.TXT 移植正点原子mini板.TXT
